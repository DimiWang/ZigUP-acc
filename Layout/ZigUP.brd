# Repository DimiWang/ZigUP-acc

File README.md:

# ZigUP - with tap detection
    + Accelerometer
    + 2 LEDS
 
CC2530 based multi-purpose ZigBee Relays, Switch, Sensor and Router

[Bottom side](https://raw.githubusercontent.com/formtapez/ZigUP/master/Pictures/bottom.jpg)

# Features

* [Small enough to fit under a normal lightswitch](https://raw.githubusercontent.com/formtapez/ZigUP/master/Pictures/size.jpg) in an european flush-mounted box ("Unterputzdose" - That´s the UP in ZigUP)
* integrated optional ZigBee Router functionality (extends the range of all your other devices)
* Powerful bistable relais for up to 10 amps load
* 2 Inputs for switches/buttons:
	* Input "KEY" directly toggles the relais and outputs a ZigBee message
	* Input "DIG" only outputs a ZigBee message - So your coordinator can decide if the relais has to be toggled or not.
* Input for 16 digital temperature (DS18B20) and 1 humidity sensors (DHT22/AM2302) (Measurements will be reported via ZigBee)
* Input for S0-Bus impulses from power-, water- or gas-meters. Count-Value will be reported via ZigBee)
* Output for one normal LED or up to 10 WS2812B/Neopixel RGB-LEDs (controllable via ZigBee)
* Analog input to measure voltages of up to 32 Volt. (Voltage will be reported via ZigBee)
* Fully equipped debug-port to allow CC Debugger flashing and packet sniffing
My version:
* Added accelerometer tap or double tap relay on/off(when mount inside 230V plug - let you manually on/off by tap)
* Added 2 leds for power and alarm when sensor.

# Connection diagrams

# Compilation

1. Get **Z-Stack Home 1.2.2a.44539** from http://www.ti.com/tool/Z-STACK-ARCHIVE
2. Get **IAR Embedded Workbench for 8051** from https://www.iar.com/iar-embedded-workbench (you can use the free trial version for one month)
3. Clone ZigUP source to **\Projects\zstack\HomeAutomation\ZigUP\\**
4. Start **\ZigUP\CC2530DB\ZigUP.eww** to load project in IAR
5. Choose between **Router** and **EndDevice** configuration
6. Edit **\Projects\zstack\Tools\CC2530DB\f8wConfig.cfg** to select the ZigBee channel your coordinator is using.
7. Compile

# Flashing with CC Debugger
1. Get **SmartRF Flash Programmer v1.12.8 (not v2.x!)** from https://www.ti.com/tool/flash-programmer
2. Connect CC Debugger to the Debug-Port of ZigUP with an 1:1 cable.
3. Select "Program CCxxxx..." and "System-on-Chip" tab
4. Load HEX-File and perform "Erase, program and verify" action

# Packet Sniffing using CC Debugger
As an alternative usage of this board, it can be used as a ZigBee packet-sniffer in combination with the CC Debugger.
1. Get **PACKET-SNIFFER v2.18.1 (not SNIFFER-2 v1.x!)** from https://www.ti.com/tool/PACKET-SNIFFER
2. Connect CC Debugger to the Debug-Port of ZigUP with an 1:1 cable.
3. Select protocol "IEEE 802.15.4/ZigBee" and click "Start"
4. Change radio channel and click "Start"
5. Re-flash ZigUP firmware when you are done, because it was replaced by a sniffer-firmware.

# Bill of Materials (BOM)

Qty | Value | Package | Parts | URL (exemplary supplier)
:--:|:----- |:------- |:------|:------------------------
5 | 100 | R0805 | R1, R3, R5, R9, R10 | https://uk.farnell.com/multicomp/mcwr08x1000ftl/res-100r-1-0-125w-0805-thick-film/dp/2447552
1 | 1k | R0805 | R8 | https://uk.farnell.com/multicomp/mcsr08x102-jtl/res-1k-5-0-125w-0805-ceramic/dp/2074338
3 | 10k | R0805 | R2, R4, R6 | https://uk.farnell.com/multicomp/mcwr08x1002ftl/res-10k-1-0-125w-0805-thick-film/dp/2447553
1 | 27k | R0805 | R7 | https://uk.farnell.com/multicomp/mcwr08x2702ftl/res-27k-1-0-125w-thick-film/dp/2447620
2 | 100n | C0805 | C4, C5 | https://uk.farnell.com/multicomp/mcu0805r104kct/cap-0-1-f-50v-10-x7r-0805/dp/9406387
3 | 10µ | C0805 | C1, C3, C6 | https://uk.farnell.com/murata/grm21br61e106ma73l/cap-10-f-25v-20-x5r-0805/dp/2611941
1 | 220µ/6V3/EEEFK0J221P | PANASONIC_D | C2 | https://uk.farnell.com/panasonic/eeefk0j221p/cap-220-f-6-3v-radial-smd/dp/1850086
8 | 4148 | 1206 | D1 - D8 | https://uk.farnell.com/taiwan-semiconductor/ts4148-rxg/diode-small-signal-75v-0-15a-1206/dp/2708388
2 | IRFML8244 | SOT23 | T1, T2 | https://uk.farnell.com/infineon/irfml8244trpbf/mosfet-n-ch-25v-5-7a-sot23/dp/1857298
1 | IRM-02-3.3 | IRM-02 | IC1 | https://uk.farnell.com/mean-well/irm-02-3-3/power-supply-ac-dc-3-3v-0-6a/dp/2815480
1 | CC2530 | E18-MS1-PCB | IC2 | https://www.aliexpress.com/item/-/32803052003.html
1 | DSP2A-L2-DC3V | DSP2A-L2 | K1 | https://uk.farnell.com/panasonic-electric-works/dsp2a-l2-dc3v/relay-dpst-no-250vac-30vdc-5a/dp/2095635
1 | MST 2.5A 250V | MST | F1 | https://uk.farnell.com/multicomp/mst-2-5a-250v/fuse-radial-slow-blow-2-5a/dp/1566104
1 | Phoenix 1792876 | PTS-3 | X1 | https://uk.farnell.com/phoenix-contact/1792876/terminal-block-wire-to-brd-3pos/dp/2072378
2 | TE 1-2834021-4 | MSC4 | X2, X3 | https://uk.farnell.com/te-connectivity/1-2834021-4/tb-wire-to-board-4pos-26-20awg/dp/2610379
1 | DEBUG | MA05-2 | X4 | https://uk.farnell.com/amphenol-icc-fci/67997-210hlf/connector-header-10pos-2row-2/dp/2886080
1 | PCB | FR4 | all | Use [Gerber files](https://github.com/formtapez/ZigUP/tree/master/Layout/Gerber) or contact me if you need a bare PCB

## EAGLE design Layout/ZigUP.brd

Parts:
C1, C3, C6: 10µ; C0805
C2: 220µ/6V3/EEEFK0J221P; E2,5-6
C4, C5, C8, C9: 100n; C0805
C7: 4.7µ; C0805
D1, D2, D3, D4, D5, D6, D7, D8: 4148; 1206
F1: MST 2.5A 250V; MST
IC1: IRM-02-3.3; IRM-01
IC2: CC2530; E18-MS1-PCB
K1: DSP2A-L2-DC3V; DSP2A-L2
LED1: RED; LED3MM
LED2: LEDSML0805; SML0805
R1, R3, R5, R9, R10: 100; R0805
R2, R4, R6, R11, R12, R13: 10k; R0805
R7: 27k; R0805
R8: 1k; R0805
R14: R-EU_R0805; R0805
T1, T2: IRFML8244; SOT23
TP1: RX; TP15SQ
TP2: TX; TP15SQ
U1: MMA8452QT; QFN50P300X300X100-16N
X1: Phoenix 1792876; PTS-3
X2, X3: TE 1-2834021-4; MSC4
X4: DEBUG; MA05-2

Connections:
!CS: IC2.11 (P1.4), X4.5
!RESET: IC2.24 (!RESET), X4.7
!S0: C4.1, D3.A, D4.K, IC2.17 (P0.6), R5.2, R6.1
+3V3: C1.1, C2.+, C3.1, C6.1, C7.2, C8.2, D1.K, D2.K, D3.K, D5.K, D7.K, IC1.V+, IC2.2 (VCC), K1.1 (+), K1.2 (+), R6.2, R11.2, R12.2, R14.1, U1.1 (VDDIO), U1.7 (SA0), U1.14 (VDD), X3.4, X4.2, X4.9
ACC_INT: IC2.15 (P1.0), U1.11 (INT1)
ACC_SCL: IC2.19 (P0.4), R11.1, U1.4 (SCL)
ACC_SDA: IC2.18 (P0.5), R12.1, U1.6 (SDA)
ADC0: C5.1, D5.A, D6.K, IC2.23 (P0.0), R7.2, R8.2
CLK: IC2.10 (P1.5), X4.6
DC: IC2.3 (P2.2), X4.3
DD: IC2.4 (P2.1), X4.4
DIG_IN: D7.A, D8.K, IC2.5 (P2.0), R10.2
GND: C1.2, C2.-, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, D4.A, D6.A, D8.A, IC1.V-, IC2.1 (GND), LED1.K (C), LED2.C, R2.1, R4.1, R8.1, T1.2 (S), T2.2 (S), U1.5 (GND_3), U1.10 (GND_2), U1.12 (GND), X2.4, X4.1
KEY: IC2.12 (P1.3), X3.1
L-FUSED: F1.2, IC1.AC/L
L-IN: F1.1, K1.8 (C), K1.9 (C), X1.1
L-OUT: K1.5 (S), K1.12 (S), X1.3
LED: IC2.22 (P0.1), R13.2
MISO: IC2.6 (P1.7), X4.10
MOSI: IC2.7 (P1.6), R9.1, X4.8
N: IC1.AC/N, X1.2
unnamed: C9.2, U1.2 (BYP)
unnamed: LED1.A, R13.1
unnamed: R7.1, X2.3
unnamed: D2.A, K1.15 (-), T2.3 (D)
unnamed: D1.A, K1.16 (-), T1.3 (D)
unnamed: R3.2, R4.2, T2.1 (G)
unnamed: R1.2, R2.2, T1.1 (G)
unnamed: R5.1, X2.2
unnamed: LED2.A, R14.2
unnamed: R9.2, X3.2
unnamed: R10.1, X3.3
OFF: IC2.13 (P1.2), R3.1
ON: IC2.14 (P1.1), R1.1
RXD: IC2.21 (P0.2), TP1.TP
SENSOR: IC2.16 (P0.7), X2.1
TXD: IC2.20 (P0.3), TP2.TP

Notes on the sheet:
max. 1.15 V (ADCref)
max. 32 V
Power supply / Switching
Relais drivers
Left connector
Right connector
Debug connector
ZigBee module
Accelerometer

Board: 2 copper layers, 52.0 x 46.0 mm, 46 parts (34 on the bottom side), 37 nets.

## Commit log

2023-02-28 Added accelerometer MMA845x
2023-03-01 final release version
2023-03-01 Gerber updated
